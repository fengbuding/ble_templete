# IAR project ble.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAC NordicSemi nRF51822-QFAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NRF51; NRF51822
  ICCARM.CCIncludePath2: ..\Library\device; ..\Library\drivers_nrf\hal; ..\Library\drivers_nrf\delay; ..\Library\toolchain; ..\Library\libraries\util; ..\Library\drivers_nrf\nrf_soc_nosd; ..\User\Main; ..\Library\libraries\simple_uart; ..\User\APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble.srec
  ILINK.IlinkOutputFile: ble.out
  ILINK.IlinkIcfFile: ble.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../User/APP/: mx25.c mx25.h
  group Application
    ../User/Main/: iar_startup_nrf51.s main.c sdk_config.h
    ../Library/drivers_nrf/delay/: nrf_delay.h
    ../Library/drivers_nrf/hal/: nrf_gpio.h
    ../Library/toolchain/: system_nrf51.c system_nrf51.h
  group nRF_Drivers
    ../Library/drivers_nrf/hal/: nrf_adc.c nrf_adc.h
  group nRF_Libraries
    ../Library/libraries/simple_uart/: simple_uart.c simple_uart.h
